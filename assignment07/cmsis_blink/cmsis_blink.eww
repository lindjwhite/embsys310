<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\assignment06\cmsis_blink\cmsis_blink.ewp</path>
    </project>
    <batchBuild />
</workspace>
